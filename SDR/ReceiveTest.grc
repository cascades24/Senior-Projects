<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CODE</value></param>
<param><key>value</key><value>'0x1011011100010110111000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>C:\Users\camil\Desktop\outPut</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>C:\Users\camil\Desktop\TestCorrel</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>C:\Users\camil\Desktop\TestDemod</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_1</value></param>
<param><key>bits_per_chunk</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>16*samp_rate*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0</value></param>
<param><key>access_code</key><value>CODE</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>constellation_points</key><value>constellation</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>16</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>constellation_points</key><value>constellation</value></param>
<param><key>samples_per_symbol</key><value>16</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>input_file1</value></param>
<param><key>file</key><value>C:\Users\camil\Desktop\11Bark.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>message_source</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>3.1e9</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>input_file1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>input_file1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>input_file1</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>message_source</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
