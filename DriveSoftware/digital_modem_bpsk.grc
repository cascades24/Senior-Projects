<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>BPSK</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_LO</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code1</value></param>
<param><key>value</key><value>'010110011011101100010101011111101001001110001011010001101010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code2</value></param>
<param><key>value</key><value>'11011010110111011000110011110101100010010011110111'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_samp_rate</value></param>
<param><key>value</key><value>1.024e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>102400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1.55</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.3</value></param>
<param><key>freq</key><value>baseband_LO</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>freq</key><value>-baseband_LO</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>input_samp_rate/10</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preamble</key><value>0101010101010101010101010101010101010101010101010101010101010</value></param>
<param><key>samples_per_symbol</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>C:\Users\CloudCover\Desktop\output.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\Users\CloudCover\Desktop\message_test.csv</value></param>
<param><key>maxoutbuf</key><value>500000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>BPSK</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>BPSK</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>0.0628</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0</value></param>
<param><key>cnst</key><value>BPSK</value></param>
<param><key>mu</key><value>.01</value></param>
<param><key>num_taps</key><value>8</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>.062</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>dacVal</key><value>125</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>oversample</key><value>1</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>rf_freq</key><value>435e6</value></param>
<param><key>samp_rate</key><value>input_samp_rate*2</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>20</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>435e6</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>10e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1.6E3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>20</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blks2_packet_encoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
